# Keil uVision project Lab6SysTick.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: switch_counter_interrupt_TivaWare
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S Lab6SysTick.c
    C:/Users/j3241/OneDrive/Documents/Desktop/Documents/GitHub/ENGR--478--LAB/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
